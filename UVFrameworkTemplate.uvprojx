# Keil uVision project UVFrameworkTemplate.uvprojx, settings and files
target BaseFrameworkTarget (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Main
    ./Source/: main.c
  group Source
    ./Source/: ADMulti.c AudioControl.c AudioShiftRegister.c Buttons.c Cities.c EnablePA25_PB23_PD7_PF0.c ES_ShortTimer.c EventCheckers.c EventGenerator.c EventPrinter.c Gameplay.c Hose.c LEDControl.c LEDShiftRegister.c Pump.c PWMTiva.c ServoControl.c Stir.c TimeOfDay.c PWM8Tiva.c PWM_Control.c IR_Pulse.c ExternalLine.c
  group Headers
    ./Headers/: ADMulti.h AudioControl.h AudioShiftRegister.h Bin_Const.h BITDEFS.H Buttons.h Cities.h EnablePA25_PB23_PD7_PF0.h ES_CheckEvents.h ES_Configure.h ES_DeferRecall.h ES_Events.h ES_Framework.h ES_General.h ES_LookupTables.h ES_Port.h ES_PostList.h ES_PriorTables.h ES_Queue.h ES_ServiceHeaders.h ES_ShortTimer.h ES_Timers.h ES_Types.h EventCheckers.h EventGenerator.h EventPrinter.h Gameplay.h Hose.h LEDControl.h LEDShiftRegister.h Pump.h PWMTiva.h ServoControl.h Stir.h termio.h TimeOfDay.h uartstdio.h PWM8Tiva.h PWM_Control.h IR_Pulse.h ExternalLine.h
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
  group Startup
    ./StartUp/: startup_rvmdk.S
  group Framework
    ./Source/: ES_CheckEvents.c ES_DeferRecall.c ES_Framework.c ES_LookupTables.c ES_Port.c ES_PostList.c ES_Queue.c ES_Timers.c retarget.c termio.c uartstdio.c
target 11-8IntegrateTest (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: as above
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target ServoTest (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: as above
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target LEDShiftTest (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: as above
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target RGB_TEST (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: as above
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
